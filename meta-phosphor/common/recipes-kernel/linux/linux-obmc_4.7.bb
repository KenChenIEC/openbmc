KBRANCH ?= "dev-4.7-lanyang"
LINUX_VERSION ?= "4.7"

SRCREV="694dc88d812b0c9e6dba364d178969e336fdd432"

require linux-obmc.inc
