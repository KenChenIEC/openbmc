SRCREV ?= "c42517e07c7b8c39d9379455e936a8d098bf0f02"
SKELETON_BRANCH = "dev-lanyang"
SKELETON_URI ?= "git://github.com/KenChenIEC/skeleton;branch=${SKELETON_BRANCH}"
